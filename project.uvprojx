# Keil uVision project project.uvprojx, settings and files
target Target 1 (6220000::V6.22::.\ARMCompiler6.22)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER, STM32H743xx
  c include: .\CMSIS;.\Drivers;.\Math;.\Middleware;.\USER;.\HALLIB\STM32H7xx_HAL_Driver\Inc;.\BSP;.\Middleware\RTOS\include;.\Middleware\RTOS;.\Middleware\RTOS\portable\ARM_CM7\r0p1;.\Middleware\RTOS\CMSIS_RTOS_V2;.\Middleware\MAVlink;.\Middleware\MAVlink\commonACFly;.\Middleware\MAVlink\minimalACFly;.\LittleFS;.\u8g2;.\Middleware\USBDevice\App;.\Middleware\USBDevice\Target;.\Middleware\USBDevice\Library;.\ControlSystem;.\Middleware\DroneCan\include;.\Middleware\DroneCan
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group USER
    ./USER/: main.cpp task_Control.cpp task_Communication.cpp task_Display.cpp task_CPUMonitor.cpp esc_node.cpp param.cpp menu.cpp stm32h7xx_it.c system_stm32h7xx.c stm32h7xx_hal_timebase_tim.c stm32h7xx_hal_msp.c
  group Dirvers
    ./Drivers/: drv_Main.cpp BMI088.cpp bmi08g.c bmi08a.c SPA06.cpp QMC5883P.cpp key.cpp TFCard.cpp uart1Driver.cpp uart3Driver.cpp led.cpp oled.cpp can.cpp KT6368A.cpp INA226.cpp buzzer.cpp
  group BSP
    ./BSP/: board.cpp DebugPort.cpp
  group Math
    ./Math/: MahonyAHRS.cpp
  group ControlSystem
    ./ControlSystem/: LQR_Control.cpp LESO.cpp
  group LittleFS
    ./LittleFS/: lfs.c lfs_util.c lfs_port.h
  group CMSIS
    ./CMSIS/: startup_stm32h743xx.s
  group HALLIB
    ./HALLIB/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_adc.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group MAVlink
    ./Middleware/MAVlink/: mavlink_bridge.cpp
  group DroneCan
    ./Middleware/DroneCan/: canard.c
    ./Middleware/DroneCan/src/: uavcan.CoarseOrientation.c uavcan.equipment.actuator.ArrayCommand.c uavcan.equipment.actuator.Command.c uavcan.equipment.actuator.Status.c uavcan.equipment.ahrs.MagneticFieldStrength.c uavcan.equipment.ahrs.MagneticFieldStrength2.c uavcan.equipment.ahrs.RawIMU.c uavcan.equipment.ahrs.Solution.c uavcan.equipment.air_data.AngleOfAttack.c uavcan.equipment.air_data.IndicatedAirspeed.c uavcan.equipment.air_data.RawAirData.c uavcan.equipment.air_data.Sideslip.c uavcan.equipment.air_data.StaticPressure.c uavcan.equipment.air_data.StaticTemperature.c uavcan.equipment.air_data.TrueAirspeed.c uavcan.equipment.camera_gimbal.AngularCommand.c uavcan.equipment.camera_gimbal.GEOPOICommand.c uavcan.equipment.camera_gimbal.Mode.c uavcan.equipment.camera_gimbal.Status.c uavcan.equipment.device.Temperature.c uavcan.equipment.esc.RawCommand.c uavcan.equipment.esc.RPMCommand.c uavcan.equipment.esc.Status.c uavcan.equipment.esc.StatusExtended.c uavcan.equipment.gnss.Auxiliary.c uavcan.equipment.gnss.ECEFPositionVelocity.c uavcan.equipment.gnss.Fix.c uavcan.equipment.gnss.Fix2.c uavcan.equipment.gnss.RTCMStream.c uavcan.equipment.hardpoint.Command.c uavcan.equipment.hardpoint.Status.c uavcan.equipment.ice.FuelTankStatus.c uavcan.equipment.ice.reciprocating.CylinderStatus.c uavcan.equipment.ice.reciprocating.Status.c uavcan.equipment.indication.BeepCommand.c uavcan.equipment.indication.LightsCommand.c uavcan.equipment.indication.RGB565.c uavcan.equipment.indication.SingleLightCommand.c uavcan.equipment.power.BatteryInfo.c uavcan.equipment.power.CircuitStatus.c uavcan.equipment.power.PrimaryPowerSupplyStatus.c uavcan.equipment.range_sensor.Measurement.c uavcan.equipment.safety.ArmingStatus.c uavcan.navigation.GlobalNavigationSolution.c uavcan.protocol.AccessCommandShell_req.c uavcan.protocol.AccessCommandShell_res.c uavcan.protocol.CANIfaceStats.c uavcan.protocol.DataTypeKind.c uavcan.protocol.debug.KeyValue.c uavcan.protocol.debug.LogLevel.c uavcan.protocol.debug.LogMessage.c uavcan.protocol.dynamic_node_id.Allocation.c uavcan.protocol.dynamic_node_id.server.AppendEntries_req.c uavcan.protocol.dynamic_node_id.server.AppendEntries_res.c uavcan.protocol.dynamic_node_id.server.Discovery.c uavcan.protocol.dynamic_node_id.server.Entry.c uavcan.protocol.dynamic_node_id.server.RequestVote_req.c uavcan.protocol.dynamic_node_id.server.RequestVote_res.c uavcan.protocol.enumeration.Begin_req.c uavcan.protocol.enumeration.Indication.c uavcan.protocol.enumeration.Begin_res.c uavcan.protocol.file.BeginFirmwareUpdate_req.c uavcan.protocol.file.BeginFirmwareUpdate_res.c uavcan.protocol.file.Delete_req.c uavcan.protocol.file.Delete_res.c uavcan.protocol.file.EntryType.c uavcan.protocol.file.Error.c uavcan.protocol.file.GetDirectoryEntryInfo_req.c uavcan.protocol.file.GetDirectoryEntryInfo_res.c uavcan.protocol.file.GetInfo_req.c uavcan.protocol.file.GetInfo_res.c uavcan.protocol.file.Path.c uavcan.protocol.file.Read_req.c uavcan.protocol.file.Read_res.c uavcan.protocol.file.Write_req.c uavcan.protocol.file.Write_res.c uavcan.protocol.GetDataTypeInfo_req.c uavcan.protocol.GetDataTypeInfo_res.c uavcan.protocol.GetNodeInfo_req.c uavcan.protocol.GetNodeInfo_res.c uavcan.protocol.GetTransportStats_req.c uavcan.protocol.GetTransportStats_res.c uavcan.protocol.GlobalTimeSync.c uavcan.protocol.HardwareVersion.c uavcan.protocol.NodeStatus.c uavcan.protocol.Panic.c uavcan.protocol.param.Empty.c uavcan.protocol.param.ExecuteOpcode_req.c uavcan.protocol.param.ExecuteOpcode_res.c uavcan.protocol.param.GetSet_req.c uavcan.protocol.param.GetSet_res.c uavcan.protocol.param.NumericValue.c uavcan.protocol.param.Value.c uavcan.protocol.RestartNode_req.c uavcan.protocol.RestartNode_res.c uavcan.protocol.SoftwareVersion.c uavcan.Timestamp.c uavcan.tunnel.Broadcast.c uavcan.tunnel.Call_req.c uavcan.tunnel.Call_res.c uavcan.tunnel.Protocol.c uavcan.tunnel.SerialConfig.c uavcan.tunnel.Targetted.c uavcan.equipment.esc.CubeSetID.c uavcan.equipment.esc.CubeCalibCommand.c uavcan.equipment.esc.CubeStatus.c uavcan.equipment.esc.CubeIqCommand.c uavcan.equipment.esc.CubeRPMCommand.c
  group RTOS
    ./Middleware/RTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Middleware/RTOS/portable/MemMang/: heap_4.c
    ./Middleware/RTOS/portable/ARM_CM7/r0p1/: port.c
    ./Middleware/RTOS/CMSIS_RTOS_V2/: cmsis_os2.c
  group u8g2
    ./u8g2/: mui.c mui_u8g2.c u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_font.c u8g2_d_setup.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c u8x8_d_ssd1306_128x64_noname.c u8x8_d_ssd1315_128x64_noname.c
  group USBDevice
    ./Middleware/USBDevice/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
    ./Middleware/USBDevice/Library/: usbd_cdc.c usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ./Middleware/USBDevice/Target/: usbd_conf.c
software components: CMSIS:CORE 5.4.0
